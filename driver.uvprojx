# Keil uVision project driver.uvprojx, settings and files
target Cortex-M0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: driver_m0 (library)
  AfterMake: .keil\copy.bat driver_m0.lib
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -fexceptions
  c include: .\src\main;.\ref\mcuf\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./src/main/: driver.h
  group main\driver
    ./src/main/driver/: package-info.h
  group main\driver\ams
    ./src/main/driver/ams/: TCS3472.cpp TCS3472.h package-info.h
  group main\driver\thermometer
    ./src/main/driver/thermometer/: package-info.h Thermistor.cpp Thermistor.h
  group main\driver\microchip
    ./src/main/driver/microchip/: MCP3421.cpp MCP3421.h package-info.h
  group main\driver\wirelesstag
    ./src/main/driver/wirelesstag/: package-info.h WT32ETH01.cpp WT32ETH01.h
  group main\driver\wirelesstag\internal
    ./src/main/driver/wirelesstag/internal/: package-info.h WT32ETH01Receiver.cpp WT32ETH01Receiver.h WT32ETH01Transfer.cpp WT32ETH01Transfer.h
target Cortex-M0PLUS (6160000::V6.16::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: driver_m0plus (library)
  AfterMake: .keil\copy.bat driver_m0plus.lib
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -fexceptions
  c include: .\src\main;.\ref\mcuf\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: driver_m3 (library)
  AfterMake: .keil\copy.bat driver_m3.lib
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -fexceptions
  c include: .\src\main;.\ref\mcuf\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M4 (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: driver_m4 (library)
  AfterMake: .keil\copy.bat driver_m4.lib
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -fexceptions
  c include: .\src\main;.\ref\mcuf\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M4F (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: driver_m4f (library)
  AfterMake: .keil\copy.bat driver_m4f.lib
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -fexceptions
  c include: .\src\main;.\ref\mcuf\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M7 (6160000::V6.16::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: driver_m7 (library)
  AfterMake: .keil\copy.bat driver_m7.lib
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\main;.\ref\mcuf\src\main
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
